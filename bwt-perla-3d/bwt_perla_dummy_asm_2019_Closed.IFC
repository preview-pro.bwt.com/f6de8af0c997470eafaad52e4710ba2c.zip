Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: bwt_perla_dummy_asm_2019_Closed.IFC
Time: 2019-04-23T08:14:41
Author: admin
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0
